# Autodesk Inventor assembly: 21.1750_5 DOOR LOCK GRAY
## iProperties
Created: 2007-03
Part Number: 21.1750_5 DOOR LOCK GRAY
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
